# Keil uVision project STM32F030_Templates.uvprojx, settings and files
target STM32F030C8T6 (ARM-ADS)
  device: STM32F030C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F030_Templates +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030x8
  c include: ..\Core;..\PPPlib\Inc;..\PPPlib\Src;..\User;..\PPPlib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group App
    ./: stm32f0xx_hal_conf.h app.c system.c stm32f0xx_it.c
  group HardWare
    ./: rcc.c timer.c usart.c gpio.c spi.c key.c flashin.c adc.c
  group CORE
    ../PPPlib/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_gpio.c stm32f0xx_hal_rcc.c stm32f0xx_hal_tim.c stm32f0xx_hal_uart.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c
    ../Core/: startup_stm32f030x8.s system_stm32f0xx.c core_cm0.h
  group Driver
    ./: oled.c 18B20.c SI24R1.c esp8266.c dht11.c mhz19b.c
software components: CMSIS:CORE 4.1.0
